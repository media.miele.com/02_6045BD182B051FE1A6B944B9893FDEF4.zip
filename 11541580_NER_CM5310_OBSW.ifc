Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 6c3b5e90-ca1b-49c9-8d1c-2031ca09604b, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T08:03:59+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11541580_NER_CM5310_OBSW:29531020_NER_11541580_CM5310_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Design_CLST, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 241 mm; Height: 360 mm; Depth: 460 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 29531020_NER_11541580_CM5310_OBSW; sets with these values: 2
